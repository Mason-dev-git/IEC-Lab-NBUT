# Keil uVision project SMART_CAR.uvprojx, settings and files
target SMART_CAR (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F767IGTx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.3.0.0
  cpu: IRAM(0x20000000-0x2007FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: SMART_CAR +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F767xx
  c include: ../Inc;../Drivers/STM32F7xx_HAL_Driver/Inc;../Drivers/STM32F7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F7xx/Include;../Drivers/CMSIS/Include;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1;../bsp;../bsp/Encoder;../bsp/key;../bsp/lcd;../bsp/led;../bsp/motor;../sys;../sys/delay;../sys/Distance_patrol;../sys/PatrolLine;../sys/pid;../sys/sys;../sys/pack;../bsp/gyroscope;../bsp/camera
  asm include: ../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x80000
  group Application/MDK-ARM
    ./: startup_stm32f767xx.s
  group Application/User
    ../Inc/: main.h gpio.h tim.h
    ../Src/: main.c gpio.c freertos.c adc.c dma.c spi.c tim.c usart.c stm32f7xx_it.c stm32f7xx_hal_msp.c stm32f7xx_hal_timebase_tim.c
  group bsp
    ../bsp/Encoder/: Encoder.cpp
    ../bsp/motor/: Motor.cpp left_motor.cpp right_motor.cpp
    ../bsp/gyroscope/: WT901C.c WT901C.h
    ../bsp/key/: key.cpp
    ../bsp/led/: led.cpp
    ../bsp/lcd/: lcd.c lcd.h lcdfont.h
    ../bsp/camera/: camera.c camera.h
  group sys
    ../sys/sys/: sys.c sys.h
    ../sys/delay/: delay.c delay.h
    ../sys/PatrolLine/: PatrolLine.cpp
    ../sys/pid/: pid.cpp pid_incremental.cpp pid_positional.cpp
    ../sys/Distance_patrol/: Distance_patrol.cpp
    ../sys/pack/: pack.cpp pack.h
    ../sys/: test.cpp test.h
  group Drivers/STM32F7xx_HAL_Driver
    ../Drivers/STM32F7xx_HAL_Driver/Inc/: stm32f7xx_hal_tim.h stm32f7xx_hal_gpio.h stm32f7xx_hal_usart.h stm32f7xx_hal_usart_ex.h stm32f7xx_hal_dma.h stm32f7xx_hal_adc.h stm32f7xx_hal_spi.h
    ../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_usart.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_adc.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_cortex.c stm32f7xx_hal.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_exti.c stm32f7xx_hal_spi.c stm32f7xx_hal_spi_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1/: port.c
software components: CMSIS:CORE 5.6.0
